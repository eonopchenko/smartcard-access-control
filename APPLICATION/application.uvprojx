# Keil uVision project application.uvprojx, settings and files
target DEBUG (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: application
  AfterMake: fromelf --bin --output=out\bin\ out\obj\application.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L1XX_MD HSE_VALUE=12000000 __DEBUG__
  c include: .\Sources\Common;.\Sources\Dummy;.\Sources\HAL;.\Sources\Signature;.\Sources\Startup;C:\Keil_v5\ARM\Pack\ARM\CMSIS\5.0.0-Beta4\CMSIS\Include;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Sources\Startup\application.sct
  group Common
    ./Sources/Common/: circular_buffer.cpp crc.cpp
  group Dummy
    ./Sources/Dummy/: vectors.cpp
  group HAL
    ./Sources/HAL/: board.cpp core.cpp data_eeprom.cpp iso7816.cpp system_timer.cpp uart.cpp watchdog_timer.cpp
  group Main
    ./Sources/: main.cpp
  group Signature
    ./Sources/Signature/: signature.cpp
  group Startup
    ./Sources/Startup/: startup.cpp
target RELEASE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: application
  AfterMake: fromelf --bin --output=out\bin\ out\obj\application.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L151xB HSE_VALUE=12000000 __RELEASE__
  c include: .\Sources\Common;.\Sources\Dummy;.\Sources\HAL;.\Sources\Signature;.\Sources\Startup;C:\Keil_v5\ARM\Pack\ARM\CMSIS\5.0.0-Beta4\CMSIS\Include\;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Sources\Startup\application.sct
